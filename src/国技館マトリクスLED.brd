# Repository issaimaru/2022_Robocon_circuit

File README.md:

# 2022_Robocon_circuit
**2022年ロボコンの回路**<br>
マスターブランチは保護されているので，各ブランチで必ずプルリクエストを送ってください．<br>

他にも[自作MD](https://github.com/Issaimaru/MoterDriver_v1)と[自作電源基板](https://github.com/Issaimaru/PowerSupply_v1)とか[モババ電源分岐させるやつ](https://github.com/Issaimaru/USB_JST-XH_CONVERTER)とかいろいろ使ったけど不具合多く見つかって成仏しそうになった<br>

回路図とピン配置をここに明記しておきます．<br>

- 上部機構
  - 回路図

    > **Warning**<br>
    > 回路図が一部変わっています．詳しくはIssaimaruまで...
  
  - ピン配置
  
    | ピン番号 | 機能 | 備考 |
    | :---: | :---: | :--: |
    | PB_8/D15 | I2C_SCL | MoterDriver-Controller v3との通信用(I2C)|
    | PB_9/D14 | I2C_SDA | 同様 |
    | PA_15 | UART_TX | 足回りのmbedとの通信用 |
    | PB_7 | UART_RX | 同様 |
    | PB_4/D5 | PWM1 | 上下機構のモータの制御用 |
    | PB_5/D4 | DIR1 | 同様 |
    | PB_10/D6 | PWM2 | 装填機構のモータの制御用 |
    | PB_3/D3 | DIR2 | 同様 |
    | PA_8/D7 | PWM3 | 射出機構のモータ制御用 |
    | PA_10/D2 | DIR3 | 同様 |
    | PA_1/A1 | LED1 | MDCとの通信確認用LED |
    | PA_4/A2 | LED2 | 足回りのmbedとの通信確認用LED |
    | PA_0/A0 | LED3 | 上下機構の速度確認用LED(PWMに対応) |
    | PB_0/A3 | LED4 | 上下機構の上昇確認用LED |
    | PC_1/A4 | LED5 | 上下機構の下降確認用LED |
    | PC_0/A6 | LED6 | 射出確認用LED |
    
- 足回り
  - 回路図

    > **Warning**<br>
    > 回路図が一部変わっています．詳しくはIssaimaruまで...
    
  - ピン配置

    | ピン番号 | 機能 | 備考 |
    | :---: | :---: | :--: |
    | PB_8/D15 | I2C_SCL | MoterDriver-Controller v3との通信用(I2C)|
    | PB_9/D14 | I2C_SDA | 同様 |
    | PA_15 | TWE_TX | TWELITEとの通信用 |
    | PB_7 | TWE_RX | 同様 |
    | PA_12 | MCU_RX | 上部機構側mbedとの通信用 |
    | PA_11 | MCU_TX | 同様 |
    | PB_4/D5 | PWM1 | 三輪メカナムの正面側モータ制御用 |
    | PB_5/D4 | DIR1 | 同様 |
    | PB_10/D6 | PWM2 | 三輪メカナムの左側面側モータの制御用 |
    | PB_3/D3 | DIR2 | 同様 |
    | PA_8/D7 | PWM3 | 三輪メカナムの右側面側モータの制御用 |
    | PA_10/D2 | DIR3 | 同様 |
    | PA_0/A0 | LED1 | MDCとの通信確認用LED |
    | PA_1/A1 | LED2 | 上部機構側mbedとの通信確認用LED |
    | PA_4/A2 | LED3 | TWELITEとの通信確認用LED |
    
- 暴走対策機能付き非常停止スイッチ
  - 回路図

  - 接続方法<br>
    - INPUT1，INPUT2はPowerUnit BseriesのMILコネクタ部のうちのVCCとGNDに無理やりはんだ付けして配線を伸ばして2ピンのJST-XHで接続してください．
    - SW_INは非常停止スイッチと接続してください．
    - CTRLはPowerUnit BseriesのCTRLと接続してください．
    - SWITCHはPowerUnit BseriesのSWITCHと接続してください．
    
 - 上部機構用エンコーダー
  - 回路図

  - ピン配置
    | ピン番号 | 機能 | 備考 |
    | :---: | :---: | :--: |
    | PB_7/D4 | I2C_SDA | メインマイコンとの通信用 |
    | PB_6/D5 | I2C_SCL | 同様 |
    | PF_0/D7 | ENC1_A | ロリコン1のA相 |
    | PF_1/D8 | ENC1_B | ロリコン1のB相 |
    | PA_8/D9 | ENC1_X | ロリコン1のX相 |
    | PA_11/D10 | ENC2_A | ロリコン2のA相 |
    | PB_5/D11 | ENC2_B | ロリコン2のB相 |
    | PB_4/D12 | ENC2_X | ロリコン2のX相 |
    | PB_1/D6 | PHOTO_OUT | フォトインタラプタの入力(HI->物体有/LOW->物体無) |
    | PA_6/A5 | RED | テープLEDの赤色点灯用ピン |
    | PA_4/A3 | GREEN | テープLEDの緑色点灯用ピン |
    | PA_3/A2 | BLUE | テープLEDの青色点灯用ピン |
    
  - 足回り用ロリコン
    - 回路図<br>
      <br>

    - ピン配置<br>
      | ピン番号 | 機能 | 備考 |
      | :---: | :---: | :--: |
      | PB_7/D4 | I2C_SDA | メインマイコンとの通信用 |
      | PB_6/D5 | I2C_SCL | 同様 |
      | PA_12/D2 | ENC1_A | ロリコン1のA相 |
      | PB_0/D3 | ENC1_B | ロリコン1のB相 |
      | PF_0/D7 | ENC2_A | ロリコン2のA相 |
      | PB_1/D6 | ENC2_B | ロリコン2のB相 |
      | PF_1/D8 | ENC3_A | ロリコン3のA相 |
      | PA_8/D9 | ENC3_B | ロリコン3のB相 |
      | PB_5/D11 | ENC4_A | ロリコン4のA相 |
      | PA_11/D10 | ENC4_B | ロリコン4のB相 |
      
  - 国技館射出
    - 回路図<br>
      <br>
      
    - ピン配置<br>
      | ピン番号 | 機能 | 備考 |
      | :---: | :---: | :--: |
      | PC_12 | UART1_TX | 足回りとの通信用 |
      | PD_2 | UART1_RX | 同様 |
      | 🌠PF_7 | UART2_TX | マトリクスLEDとの通信用 |
      | 🌠PF_6 | UART2_RX | 同様 |
      | 🌠PA_10 | PWM1 | モータ駆動用PWM出力ピン |
      | 🌠PB_3 | PWM2 | 同様 |
      | 🌠PB_5 | PWM3 | 同様 |
      | 🌠PB_4 | PWM4 | 同様 |
      | 🌠PA_3 | PWM5 | 同様 |
      | 🌠PA_2 | PWM6 | 同様 |
      | 🌠PC_7 | DIR1 | モータ回転方向信号出力ピン |
      | 🌠PA_9 | DIR2 | 同様 |
      | 🌠PA_8 | DIR3 | 同様 |
      | 🌠PB_10 | DIR4 | 同様 |
      | 🌠PA_7 | DIR5 | 同様 |
      | 🌠PB_6 | DIR6 | 同様 |
      | PD_5 | ENC1_B | ロリコン1のB相 |
      | PD_6 | ENC1_A | ロリコン1のA相 |
      | PD_7 | ENC2_B | ロリコン2のB相 |
      | PE_3 | ENC2_A | ロリコン2のA相 |
      | PF_1 | ENC3_B | ロリコン3のB相 |
      | PF_0 | ENC3_A | ロリコン3のA相 |
      | PD_1 | ENC4_B | ロリコン4のB相 |
      | PD_0 | ENC4_A | ロリコン4のA相 |
      | PG_0 | ENC5_B | ロリコン5のB相 |
      | PE_1 | ENC5_A | ロリコン5のA相 |
      | PG_9 | ENC6_B | ロリコン6のB相 |
      | PG_12 | ENC6_A | ロリコン6のA相 |
      | PD_14 | RED | テープLED 赤色 |
      | PD_15 | GREEN | テープLED 緑色 |
      | PE_9 | BLUE | テープLED 青色 |
      | PF_11 | LED1 | 確認用LED(任意) |
      | PE_0 | LED2 | 同様 |
      | PG_8 | LED3 | 同様 |
      | PG_5 | LED4 | 同様 |
      | PG_6 | LED5 | 同様 |

  - 国技館足回り
    - 回路図<br>
      <br>
      
    - ピン配置<br>
      | ピン番号 | 機能 | 備考 |
      | :---: | :---: | :--: |
      | PA_15 | UART1_TX | IM920sLとの通信用 |
      | PB_7 | UART1_RX | 同様 |
      | PA_11 | UART2_TX | 射出マイコンとの通信用 |
      | PA_12 | UART2_RX | 同様 |
      | D6/PB_10 | PWM1 | モータ駆動用PWM出力ピン |
      | D7/PA_8 | PWM2 | 同様 |
      | D8/PA_9 | PWM3 | 同様 |
      | D9/PC_7 | PWM4 | 同様 |
      | Pc_4 | DIR1 | モータ回転方向信号出力ピン |
      | PB_12 | DIR2 | 同様 |
      | PC_5 | DIR3 | 同様 |
      | PC_6 | DIR4 | 同様 |
      | PA_13 | ENC1_B | ロリコン1のB相 |
      | PA_14 | ENC1_A | ロリコン1のA相 |
      | PC_14 | ENC2_B | ロリコン2のB相 |
      | PC_15 | ENC2_A | ロリコン2のA相 |
      | PH_0 | ENC3_B | ロリコン3のB相 |
      | PH_1 | ENC3_A | ロリコン3のA相 |
      | PC_2 | ENC4_B | ロリコン4のB相 |
      | PC_3 | ENC4_A | ロリコン4のA相 |
      | A1/PA_1 | SLEEP | IM920sLのSLEEPピン |
      | A2/PA_4 | RESET | IM920sLのRESETピン |
      | A3/PB_0 | STATUS | IM920sLのSTATUSピン |
      | A4/PC_1 | XMIT | IM920sLのXMITピン |
      | A6/PC_0 | BUSY | IM920sLのBUSYピン |
      | PB_2 | LED1 | 確認用LED |
      | PB_1 | LED2 | 同様 |
      | PB_15 | LED3 | 同様 |
      | PB_14 | LED4 | 同様 |
      | PB_13 | LED5 | 同様 |
      
  - 国技館コントローラ
    - 回路図<br>

    - ピン配置<br>
      | ピン番号 | 機能 | 備考 |
      | :---: | :---: | :--: |
      | PC_10 | CK1_UP | 左十字キー↑ |
      | PC_12 | CK1_LEFT | 左十字キー← |
      | PD_2 | CK1_RIGHT | 左十字キー→ |
      | PC_11 | CK1_DOWN | 左十字キー↓ |
      | D3/PB_3 | CK2_UP | 右十字キー↑ |
      | D5/PB_4 | CK2_LEFT | 右十字キー← |
      | D4/PB_5 | CK2_RIGHT | 右十字キー→ |
      | D2/PA_10 | CK2_DOWN | 右十字キー↓ |
      | PB_14 | BL1 | 左トリガーL1 |
      | PB_13 | BL2 | 左トリガーL2 |
      | PB_1 | BR1 | 右トリガーR1 |
      | PB_15 | BR2 | 右トリガーR2 |
      | A0/PA_0 | L/R1 | 左アナログスティックx軸 |
      | A1/PA_1 | U/D1 | 左アナログスティックy軸 |
      | A2/PA_4 | L/R2 | 右アナログスティックx軸 |
      | A3/PB_0 | U/D2 | 右アナログスティックy軸 |
      | PA_13 | EME_SW | 非常停止スイッチ入力(HIGH:開 LOW:閉) |
      | PA_15 | TX | IM920sL通信用 |
      | PB_7 | RX | 同様 |
      | PH_1 | XMIT | IM920sLのドキュメント参照 |
      | PC_2 | SLEEP | 同様 |
      | PC_3 | STATUS | 同様 |
      | A6/PC_0 | BUSY | 同様 |
      | A4/PC_1 | RESET | 同様 |
      | D14/PB_9 | LED1 | 確認用LED |
      | D15/PB_8 | LED2 | 同様 |
      | PC_9 | LED3 | 同様 | 
      | PC_8 | LED4 | 同様 |
      | PC_6 | LED5 | 同様 |

## EAGLE design src/国技館マトリクスLED.brd

Parts:
JP1, JP2, JP3, JP4, JP5, JP12: PINHD-1X5; 1X05
JP13: 05-JST; B5B-XH

Connections:
CLK: JP1.1, JP13.5
CS: JP1.2, JP13.4
DIN: JP1.3, JP13.3
GND: JP1.4, JP13.2
unnamed: JP2.1, JP3.1
unnamed: JP2.2, JP3.2
unnamed: JP2.3, JP3.3
unnamed: JP2.4, JP3.4
unnamed: JP2.5, JP3.5
unnamed: JP4.1, JP5.1
unnamed: JP4.2, JP5.2
unnamed: JP4.3, JP5.3
unnamed: JP4.4, JP5.4
unnamed: JP4.5, JP5.5
VCC: JP1.5, JP13.1

Board: 2 copper layers, 8 parts (0 on the bottom side), 15 nets.

Other parts of the board:
U$1: TYPE.A

## EAGLE design src/国技館マトリクスLED制御器.brd

Parts:
C1: 100nF; C025-024X044
GND共通: 02-JST; B2B-XH
JP1, JP2: PINHD-1X17; 1X17
JP4, JP5: PINHD-1X10; 1X10
LED1, LED2: LED3MM
MAT_LED: 05-JST; B5B-XH
R1: 150; 0204/7
R2: 100; 0204/7
U$1: 02-JST; B2B-XH
VIN: 02-JST; B2B-XH

Connections:
3V3: JP1.2, JP5.1
5V: JP1.12, JP4.1, MAT_LED.1
D10: JP2.3, R2.1
D11: JP2.2, MAT_LED.3
D12: JP2.1, MAT_LED.4
D13: JP1.1, MAT_LED.5
GND: C1.2, GND共通.1, JP1.14, JP4.10, LED1.K (C), LED2.K (C), MAT_LED.2, VIN.1
MRX: JP5.3, U$1.2
MTX: JP5.2, U$1.1
unnamed: LED1.A, R1.2
unnamed: LED2.A, R2.2
RX: JP2.14, JP4.3
TX: JP2.15, JP4.2
VIN: C1.1, JP1.15, R1.1, VIN.2

Notes on the sheet:
FXMA108
Arduino

Board: 2 copper layers, 14 parts (0 on the bottom side), 14 nets.

Other parts of the board:
U$2: TYPE.B

## EAGLE design src/2022国技館射出.brd

Parts:
C1: C-EU025-024X044; C025-024X044
ENC1, ENC2, ENC3, ENC4, ENC5, ENC6: 05-JST; B5B-XH
JP5, JP6: PINHD-2X30; 2X30
JP7, JP8: PINHD-2X6; 2X06
JP9: 04-JST; B4B-XH
LED1, LED2, LED3, LED4, LED5, LED6: LED5MM
MAT_LED: 02-JST; B2B-XH
POW: 02-JST; B2B-XH
R1, R2, R3, R4, R5, R6, R7: 100; 0204/7
SUSPENSION: 02-JST; B2B-XH
SV1, SV2: ML10

Connections:
3V3: JP6.7, SV1.2, SV2.2
5V: ENC1.4, ENC2.4, ENC3.4, ENC4.4, ENC5.4, ENC6.4, JP5.18
BLUE: JP6.52, JP9.2
DIR1: JP6.19, SV1.9
DIR2: JP6.21, SV1.7
DIR3: JP6.23, SV1.5
DIR4: JP6.25, SV1.3
DIR5: JP6.15, SV2.9
DIR6: JP6.17, SV2.7
ENC1_A: ENC1.3, JP5.43
ENC1_B: ENC1.5, JP5.41
ENC2_A: ENC2.3, JP5.47
ENC2_B: ENC2.5, JP5.45
ENC3_A: ENC3.3, JP5.53
ENC3_B: ENC3.5, JP5.51
ENC4_A: ENC4.3, JP5.57
ENC4_B: ENC4.5, JP5.55
ENC5_A: ENC5.3, JP7.1
ENC5_B: ENC5.5, JP5.59
ENC6_A: ENC6.3, JP7.5
ENC6_B: ENC6.5, JP7.3
GND: C1.2, ENC1.1, ENC2.1, ENC3.1, ENC4.1, ENC5.1, ENC6.1, JP5.22, JP6.54, JP9.1, LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), POW.1, SV1.1, SV2.1
GREEN: JP6.48, JP9.3
LED1: JP8.2, R2.1
LED2: JP8.4, R3.1
LED3: JP8.6, R4.1
LED4: JP8.8, R5.1
LED5: JP8.10, R6.1
unnamed: LED1.A, R1.2, R7.2
unnamed: LED2.A, R2.2
unnamed: LED3.A, R3.2
unnamed: LED4.A, R4.2
unnamed: LED5.A, R5.2
unnamed: LED6.A, R6.2
PWM1: JP6.33, SV1.10
PWM2: JP6.31, SV1.8
PWM3: JP6.29, SV1.6
PWM4: JP6.27, SV1.4
PWM5: JP6.37, SV2.10
PWM6: JP6.35, SV2.8
RED: JP6.46, JP9.4
RX1: JP5.4, SUSPENSION.1
RX2: JP5.9, MAT_LED.1
TX1: JP5.3, SUSPENSION.2
TX2: JP5.11, MAT_LED.2
VIN: C1.1, JP5.24, POW.2, R1.1, R7.1

Notes on the sheet:
NUCLEO-F767ZI
Encoder
Moter
POW
UART
RGB LED
超高輝度LED!
LED

Board: 2 copper layers, 32 parts (0 on the bottom side), 46 nets.

Other parts of the board:
U$1, U$2: TYPE.A

## EAGLE design src/2022国技館足回り.brd

Parts:
C1: 100nF; C025-024X044
JP1, JP2: PINHD-2X19; 2X19
JP3, JP4, JP5, JP6: 05-JST; B5B-XH
JP8, JP9: PINHD-1X8; 1X08
LED1, LED2, LED3, LED4, LED5, LED6: LED5MM
POW: 02-JST; B2B-XH
R1: 100; 0204/7
R2, R3, R4, R5, R6: 100; 0207/2V
REMOTE_SW: 02-JST; B2B-XH
SUSPENSION: 02-JST; B2B-XH
SV1: ML10

Connections:
3V3: JP1.16, JP8.7, SV1.2
5V: JP1.18, JP3.4, JP4.4, JP5.4, JP6.4
BUSY: JP1.38, JP8.1
DIR1: JP2.34, SV1.9
DIR2: JP2.16, SV1.7
DIR3: JP2.6, SV1.5
DIR4: JP2.4, SV1.3
EMERGENCY: JP2.2, REMOTE_SW.2
ENC1_A: JP1.15, JP3.3
ENC1_B: JP1.13, JP3.5
ENC2_A: JP1.3, JP4.3
ENC2_B: JP1.1, JP4.5
ENC3_A: JP2.3, JP5.3
ENC3_B: JP2.5, JP5.5
ENC4_A: JP1.37, JP6.3
ENC4_B: JP1.35, JP6.5
GND: C1.2, JP1.20, JP3.1, JP4.1, JP5.1, JP6.1, JP9.8, LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), POW.1, REMOTE_SW.1, SV1.1
LED1: JP2.22, R2.1
LED2: JP2.24, R3.1
LED3: JP2.26, R4.1
LED4: JP2.28, R5.1
LED5: JP2.30, R6.1
unnamed: LED3.A, R3.2
unnamed: LED2.A, R2.2
unnamed: LED1.A, R1.2
unnamed: LED6.A, R6.2
unnamed: LED5.A, R5.2
unnamed: LED4.A, R4.2
PWM1: JP2.25, SV1.10
PWM2: JP2.23, SV1.8
PWM3: JP2.21, SV1.6
PWM4: JP2.19, SV1.4
RESET: JP1.32, JP8.8
RX1: JP1.21, JP8.4
RX2: JP2.14, SUSPENSION.1
SLEEP: JP1.30, JP9.2
STATUS: JP1.34, JP8.6
TX1: JP1.17, JP9.3
TX2: JP2.12, SUSPENSION.2
VIN: C1.1, JP1.24, POW.2, R1.1
XMIT: JP1.36, JP8.2

Notes on the sheet:
Encoder
UART
Moter
IM920sL
POW
NUCLEO-F411RE
LED
EMERGENCY

Board: 2 copper layers, 26 parts (1 on the bottom side), 41 nets.

Other parts of the board:
U$1: TYPE.A

## EAGLE design src/電源スイッチ.brd

Parts:
OUTPUT: 02-JST; B2B-XH
SW1, SW2: 03-JST; B3B-XH
USB: 02-JST; B2B-XH

Connections:
5V: SW1.2, SW2.2, USB.2
GND: OUTPUT.1, USB.1
ON_SW: OUTPUT.2, SW1.3, SW2.3

Notes on the sheet:
USB
ON_Switch
OUTPUT

Board: 2 copper layers, 5 parts (0 on the bottom side), 3 nets.

Other parts of the board:
U$1: TYPE.C

## EAGLE design src/2022国技館遠隔非常停止回路.brd

Parts:
MCU: 03-JST; B3B-XH
R1: 10k; 0204/7
SW: 02-JST; B2B-XH

Connections:
GND: MCU.1, R1.1
INPUT: MCU.2, R1.2, SW.1
VCC: MCU.3, SW.2

Board: 2 copper layers, 4 parts (0 on the bottom side), 3 nets.

Other parts of the board:
U$1: TYPE.C

## EAGLE design src/2022国技館コントローラ.brd

Parts:
BL1, BL2: 02-JST; B2B-XH
BR1, BR2: 02-JST; B2B-XH
C1, C2, C3: 100nF; C025-024X044
CK1_DOWN, CK1_LEFT, CK1_RIGHT, CK1_UP, CK2_DOWN, CK2_LEFT, CK2_RIGHT, CK2_UP: 02-JST; B2B-XH
F411RE_LEFT, F411RE_RIGHT: PINHD-2X19; 2X19
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: PINHD-1X2; 1X02
LED_MAT: 05-JST; B5B-XH
PWR: 02-JST; B2B-XH
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 10k; 0204/7
SV1: ML10
U$3, U$4: 02-JST; B2B-XH

Connections:
3V3: BL1.2, BL2.2, BR1.2, BR2.2, C1.1, C2.1, CK1_DOWN.2, CK1_LEFT.2, CK1_RIGHT.2, CK1_UP.2, CK2_DOWN.2, CK2_LEFT.2, CK2_RIGHT.2, CK2_UP.2, F411RE_LEFT.16, F411RE_RIGHT.7, JP1.1, JP3.1, JP5.1, JP7.1, SV1.3; also elsewhere on the board
BL1: BL1.1, F411RE_RIGHT.28, R10.1
BL2: BL2.1, F411RE_RIGHT.30, R9.1
BR1: BR1.1, F411RE_RIGHT.24, R11.1
BR2: BR2.1, F411RE_RIGHT.26, R12.1
BUSY: F411RE_LEFT.38, SV1.10
CK1_DOWN: CK1_DOWN.1, F411RE_LEFT.2, R2.1
CK1_LEFT: CK1_LEFT.1, F411RE_LEFT.3, R1.1
CK1_RIGHT: CK1_RIGHT.1, F411RE_LEFT.4, R3.1
CK1_UP: CK1_UP.1, F411RE_LEFT.1, R4.1
CK2_DOWN: CK2_DOWN.1, F411RE_RIGHT.33, R8.1
CK2_LEFT: CK2_LEFT.1, F411RE_RIGHT.27, R5.1
CK2_RIGHT: CK2_RIGHT.1, F411RE_RIGHT.29, R7.1
CK2_UP: CK2_UP.1, F411RE_RIGHT.31, R6.1
EME_SW: F411RE_LEFT.13; also elsewhere on the board
GND: C1.2, C2.2, C3.2, F411RE_LEFT.8, F411RE_LEFT.19, F411RE_LEFT.22, F411RE_RIGHT.20, JP2.2, JP6.2, PWR.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, SV1.7; also elsewhere on the board
L/R1: F411RE_LEFT.28, JP1.2
L/R2: F411RE_LEFT.32, JP5.2, U$3.2, U$4.2
LED1: F411RE_RIGHT.5, LED_MAT.5; also elsewhere on the board
LED2: F411RE_RIGHT.3, LED_MAT.4; also elsewhere on the board
LED3: F411RE_RIGHT.1, LED_MAT.3; also elsewhere on the board
LED4: F411RE_RIGHT.2, LED_MAT.2; also elsewhere on the board
LED5: F411RE_RIGHT.4, LED_MAT.1; also elsewhere on the board
RESET: F411RE_LEFT.36, SV1.9
RX: F411RE_LEFT.21, SV1.2
SLEEP: F411RE_LEFT.35, SV1.6
STATUS: F411RE_LEFT.37, SV1.8
TX: F411RE_LEFT.17, SV1.5
U/D1: F411RE_LEFT.30, JP2.1
U/D2: F411RE_LEFT.34, JP6.1, U$3.1, U$4.1
VIN: C3.1, F411RE_LEFT.24, PWR.2
XMIT: F411RE_LEFT.31, SV1.4

Notes on the sheet:
JoyStick_Left
JoyStick_Right
MCU
CROSS_KEY_LEFT
CROSS_KEY_RIGHT
Trigger_Left
Trigger_Right
External Charging
MIL Connecter
LED
Analogpin

Board: 2 copper layers, 45 parts (1 on the bottom side), 32 nets.

Other parts of the board:
EMERGENCY: B3B-XH
LED: B6B-XH
U$1, U$2: TYPE.B

Their connections:
3V3: EMERGENCY.3; also elsewhere on the board
EME_SW: EMERGENCY.2; also elsewhere on the board
GND: EMERGENCY.1, LED.1; also elsewhere on the board
LED1: LED.6; also elsewhere on the board
LED2: LED.5; also elsewhere on the board
LED3: LED.4; also elsewhere on the board
LED4: LED.3; also elsewhere on the board
LED5: LED.2; also elsewhere on the board

## EAGLE design src/国技館_IM920sL.brd

Parts:
JP1, JP2: PINHD-1X8; 1X08
SV1: ML10

Connections:
3V3: JP1.7, SV1.3
BUSY: JP1.1, SV1.10
GND: JP2.8, SV1.7
RESET: JP1.8, SV1.9
RX: JP2.3, SV1.2
SLEEP: JP2.2, SV1.6
STATUS: JP1.6, SV1.8
TX: JP1.4, SV1.5
XMIT: JP1.2, SV1.4

Notes on the sheet:
IM920sL
MIL

Board: 2 copper layers, 4 parts (0 on the bottom side), 9 nets.

Other parts of the board:
U$1: TYPE.C

## Commit log

2022-07-12 [add]srcの追加
2022-07-12 [add]メイン回路の追加
2022-07-12 [add]メイン回路 Issaimaru側の追加
2022-07-13 [add]コントローラー回路図の追加，メイン基板続き
2022-07-29 [add]main kairo Aoi
2022-08-02 [add]コントローラに対する進捗dxを生成✅
2022-08-02 [add]コントローラー.brdの追加
2022-08-02 [fix]コントローラー.brdの修正
2022-08-04 [add]メイン回路
2022-08-04 [add]コントローラ
2022-08-17 [move]ファイルの移動
2022-08-18 メイン回路
2022-08-18 [fix]受信側の回路のsch修正全て
2022-08-18 [fix]brd途中まで変更
2022-08-19 [complete]メイン回路2の完成
2022-08-19 [fix]メイン回路2.schの修正
2022-08-19 [complete]メイン回路1の完成
2022-08-21 [add]暴走対策回路の追加--ここから--
2022-08-21 [complete]メイン回路1の暴走対策回路の配線完了
2022-08-22 [add]メイン回路1にソケット置きを追加
2022-08-22 [fix]接続問題の解消
2022-08-22 [fix]メイン回路1にソケット置きを追加
2022-08-22 [complete]メイン回路2に暴走対策回路を追加
2022-08-22 暴走対策機能付き非常停止スイッチ
2022-08-30 [add]コントローラAoi
2022-08-31 暴走対策機能付き非常停止スイッチの回路のガバを修復
2022-08-31 回路図の追加
2022-08-31 [add]コントローラ Aoi
2022-09-23 配線をDriveUnit ver2.0用に変更
2022-09-30 エンコーダー回路追加
2022-10-01 上部機構用エンコーダー 回路の微修正
2022-10-30 国技館コントローラの追加
2022-10-31 「ｋ」コントローラ
2022-11-01 国技館コントローラ_配線の修正
2022-11-01 [k]コントローラ
2022-11-01 足回りなど
2022-11-02 国技館足回り回路の追加
2022-11-03 2022/11/03
2022-11-03 2022国技館射出完成
2022-11-03 LEDsの追加
2022-11-03 足回りコントローラ
2022-11-03 国技館_IM920sLの追加
2022-11-03 助けてー進捗に襲われてまーす
2022-11-06 国技館足回り修正前
2022-11-06 国技館足回り修正後
2022-11-06 11/06日の進捗
2022-11-08 11/08修正
2022-12-06 [add]コントローラtw
