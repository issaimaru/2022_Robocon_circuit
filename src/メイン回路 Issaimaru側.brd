# Repository issaimaru/2022_Robocon_circuit

## EAGLE design src/メイン回路 Issaimaru側.brd

Parts:
F303RE_LEFT: PINHD-2X19; 2X19
TWE_L: PINHD-1X14; 1X14
TWE_R: PINHD-1X14; 1X14
UART: 02-JST; B2B-XH
遠野: ML10

Connections:
3V3: F303RE_LEFT.15, TWE_R.1, 遠野.2
DIR1: F303RE_LEFT.29, 遠野.9
DIR2: F303RE_LEFT.31, 遠野.7
DIR3: F303RE_LEFT.33, 遠野.5
GND: F303RE_LEFT.19, TWE_L.1, 遠野.1
PWM1: F303RE_LEFT.38, 遠野.10
PWM2: F303RE_LEFT.37, 遠野.8
PWM3: F303RE_LEFT.35, 遠野.6
RX_MCU: F303RE_LEFT.1, UART.1
RX_TWE: F303RE_LEFT.18, TWE_L.3
TX_MCU: F303RE_LEFT.2, UART.2
TX_TWE: F303RE_LEFT.16, TWE_L.10

Board: 2 copper layers, 5 parts (0 on the bottom side), 12 nets, no tracks yet.

## EAGLE design src/メイン回路１.brd

Parts:
F411RE_L, F411RE_R: PINHD-2X19; 2X19
LED1, LED2, LED3: LED5MM
MCU_UART: 02-JST; B2B-XH
MDC: 04-JST; B4B-XH
PUB: ML10
R4, R5, R7: 2.2k; 0204/7
R6, R9, R10: 100; 0204/7
R8: 3.3k; 0204/7
TWE_L: PINHD-1X14; 1X14
TWE_R: PINHD-1X14; 1X14

Connections:
3V: PUB.2, R7.1, R8.2
3V3: F411RE_L.16, TWE_R.1
DIR1: F411RE_R.29, PUB.9
DIR2: F411RE_R.31, PUB.7
DIR3: F411RE_R.33, PUB.5
DIR4: F411RE_R.34, PUB.3
GND: F411RE_L.20, F411RE_L.22, F411RE_R.20, LED1.K (C), LED2.K (C), LED3.K (C), MDC.4, PUB.1, R8.1, TWE_L.1
LED1: F411RE_L.28, R6.1
LED2: F411RE_L.30, R9.1
LED3: F411RE_L.32, R10.1
unnamed: LED2.A, R9.2
unnamed: LED1.A, R6.2
unnamed: LED3.A, R10.2
PWM1: F411RE_R.27, PUB.10
PWM2: F411RE_R.25, PUB.8
PWM3: F411RE_R.23, PUB.6
PWM4: F411RE_R.21, PUB.4
RX: F411RE_L.17, TWE_L.3
RX_MCU: F411RE_R.12, MCU_UART.2
SCL: F411RE_R.3, MDC.3, R5.1
SDA: F411RE_R.5, MDC.2, R4.1
TX: F411RE_L.21, TWE_L.10
TX_MCU: F411RE_R.14, MCU_UART.1
U5V: F411RE_R.8, MDC.1, R4.2, R5.2, R7.2

Notes on the sheet:
TX，RXはTWELITE基準
Designed by Issaimaru
足回り 2022-Robocon
受信確認用1(MDC)
受信確認用2(MCU)
受信確認用3(TWE)
MCU_COM
CONVERTER
TWELITE
MCU
MDC_COM
MOTOR
LED

Board: 2 copper layers, 19 parts (1 on the bottom side), 24 nets.

Other parts of the board:
U$1, U$2: TYPE.B

## EAGLE design src/メイン回路２.brd

Parts:
D1, D2, D3, D4, D5, D6: 1N4004; DO41-10
DEBUG: PINHD-1X2; 1X02
F411RE_L, F411RE_R: PINHD-2X19; 2X19
LED1, LED2, LED3, LED4, LED5, LED6: LED5MM
MCU_UART: 02-JST; B2B-XH
MDC: 04-JST; B4B-XH
PUB: ML10
R1, R2, R3: 330; 0204/7
R4, R5, R7: 2.2k; 0204/7
R6, R9, R10, R11, R12, R13: 100; 0204/7
R8: 3.3k; 0204/7
R14, R15: 10k; 0204/7
T1, T2, T3, T4: 一般的なトランジスタ; TO92-CEB
ソケット置き: PINHD-1X2; 1X02

Connections:
3V: PUB.2, R7.1, R8.2
DEBUG: D4.A, D5.A, D6.A, DEBUG.2, R14.1
DIR1: D4.C, F411RE_R.29, PUB.9
DIR2: D5.C, F411RE_R.31, PUB.7
DIR3: D6.C, F411RE_R.33, PUB.5
GND: F411RE_L.20, F411RE_L.22, F411RE_R.20, LED1.K (C), LED2.K (C), LED3.K (C), LED4.K (C), LED5.K (C), LED6.K (C), MDC.4, PUB.1, PUB.3, PUB.4, R1.1, R2.1, R3.1, R8.1, T1.E
LED1: F411RE_L.30, R6.1
LED2: F411RE_L.32, R9.1
LED3: F411RE_L.28, R10.1
LED4: F411RE_L.34, R11.1
LED5: F411RE_L.36, R12.1
LED6: F411RE_L.38, R13.1
unnamed: LED2.A, R9.2
unnamed: LED1.A, R6.2
unnamed: LED3.A, R10.2
unnamed: LED4.A, R11.2
unnamed: LED5.A, R12.2
unnamed: LED6.A, R13.2
unnamed: R14.2, T1.B
unnamed: D1.A, PUB.10, R1.2, T4.E
unnamed: D2.A, PUB.8, R2.2, T3.E
N$Q0: D3.A, PUB.6, R3.2, T2.E
PWM1: D1.C, F411RE_R.27, T4.C
PWM2: D2.C, F411RE_R.25, T3.C
PWM3: D3.C, F411RE_R.23, T2.C
RX_MCU: F411RE_L.21, MCU_UART.1
SCL: F411RE_R.3, MDC.3, R5.1
SDA: F411RE_R.5, MDC.2, R4.1
TX_MCU: F411RE_L.17, MCU_UART.2
U5V: DEBUG.1, F411RE_R.8, MDC.1, R4.2, R5.2, R7.2, R15.2
ZM: R15.1, T1.C, T2.B, T3.B, T4.B

Notes on the sheet:
Designed by Issaimaru
受信確認用1(MDC)
受信確認用2(MCU)
速度確認用(PWM)
上昇確認用
下降確認用
射出確認用
上部機構 2022-Robocon
MCU_COM
MDC_COM
MCU
CONVERTER
LED
MOTOR
SOCKET

Board: 2 copper layers, 40 parts (4 on the bottom side), 31 nets.

Other parts of the board:
U$2, U$3: TYPE.B

## EAGLE design src/暴走対策機能付き非常停止スイッチ.brd

Board: 2 copper layers, 14 parts (0 on the bottom side), 11 nets.

Parts:
CTRL: 02-JST; B2B-XH
INPUT1, INPUT2: 02-JST; B2B-XH
IRLB-1: IRLB3813STAND; TO-220AB-STAND
OK1: PC817; DIL04
R1, R2, R5, R6: 10k; 0204/7
R3: 100; 0204/7
SWITCH: 02-JST; B2B-XH
SW_IN: 02-JST; B2B-XH
T2: 一般的なトランジスタ; TO92-CEB
U$1: TYPE.C

Connections:
GND: INPUT1.1, INPUT2.1, R1.1, R3.2
GND2: CTRL.1, OK1.3
INPUT: IRLB-1.D, SWITCH.1
unnamed: SW_IN.1, T2.C
unnamed: INPUT1.2, SW_IN.2
unnamed: OK1.1, R1.2, R6.1, T2.E
unnamed: INPUT2.2, R2.1
unnamed: R2.2, R6.2, T2.B
unnamed: OK1.2, R3.1
unnamed: IRLB-1.G, OK1.4, R5.1
VCC: IRLB-1.S, R5.2, SWITCH.2

## EAGLE design メイン回路１.brd

Board: 2 copper layers, 8 parts (1 on the bottom side), 14 nets.

Parts:
JP1, JP2: 1X14
JP3, JP4: 2X19
SV1: ML10
U$1: 02-JST; B2B-XH
U$2, U$3: TYPE.B

Connections:
unnamed: JP4.1, SV1.4
unnamed: JP4.3, SV1.6
unnamed: JP4.5, SV1.8
unnamed: JP4.19, SV1.10
unnamed: JP4.37, SV1.3
unnamed: JP4.35, SV1.5
unnamed: JP4.33, SV1.7
unnamed: JP4.31, SV1.9
unnamed: JP4.10, SV1.1
unnamed: JP3.16, SV1.2
unnamed: JP3.2, U$1.2
unnamed: JP3.1, U$1.1
unnamed: JP1.3, JP3.15
unnamed: JP1.10, JP3.17
